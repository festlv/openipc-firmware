## general/package/visca-server/Config.in
```kconfig
config BR2_PACKAGE_VISCA_SERVER
	bool "visca-server"
	help
	  visca-server - VISCA serial server
```
